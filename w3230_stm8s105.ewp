# IAR project w3230_stm8s105.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: w3230_stm8s105.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c adc.h comms.c comms.h delay.c delay.h eep.c eep.h i2c_bb.c i2c_bb.h max6675.c max6675.h misc.c misc.h pid.c pid.h ring_buffer.h scheduler.c scheduler.h spi.c spi.h uart.c uart.h w3230_lib.c w3230_lib.h w3230_main.c w3230_main.h
